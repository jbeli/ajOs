# Keil uVision project ajOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ajOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: .\os;.\peripherals;.\conf
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group osKernel
    ./os/: osKernel.c osKernel.h osCounter.c osCounter.h osTask.c osTask.h osTypes.h OsCfg.c OsCfg.h OsSchedulerCfg.h
  group periph
    ./peripherals/: gpio.c gpio.h
  group User
    ./: main.c SWC_1.c
  group conf
    ./conf/: compiler.h
  group Types
    ./: TaskTypes.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
